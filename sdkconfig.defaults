## sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"

CONFIG_ESP32_SPIRAM_SUPPORT=y

CONFIG_HTTPD_MAX_REQ_HDR_LEN=1024
```
